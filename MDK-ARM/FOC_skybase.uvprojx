# Keil uVision project FOC_skybase.uvprojx, settings and files
target FOC_skybase (6210000::V6.21::ARMCLANG)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: FOC_skybase +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_FULL_LL_DRIVER,USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../USB_Device/App;../USB_Device/Target;C:/Users/10548/STM32Cube/Repository/STM32Cube_FW_G4_V1.5.1/Drivers/STM32G4xx_HAL_Driver/Inc;C:/Users/10548/STM32Cube/Repository/STM32Cube_FW_G4_V1.5.1/Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;C:/Users/10548/STM32Cube/Repository/STM32Cube_FW_G4_V1.5.1/Middlewares/ST/STM32_USB_Device_Library/Core/Inc;C:/Users/10548/STM32Cube/Repository/STM32Cube_FW_G4_V1.5.1/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;C:/Users/10548/STM32Cube/Repository/STM32Cube_FW_G4_V1.5.1/Drivers/CMSIS/Device/ST/STM32G4xx/Include;C:/Users/10548/STM32Cube/Repository/STM32Cube_FW_G4_V1.5.1/Drivers/CMSIS/Include;../Code/Inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Code/Src/: delay.c
    ../Core/Src/: main.c gpio.c adc.c dma.c fdcan.c lptim.c spi.c tim.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Application/User/USB_Device/Target
    ../USB_Device/Target/: usbd_conf.c
  group Application/User/USB_Device/App
    ../USB_Device/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Drivers/STM32G4xx_HAL_Driver
    C:/Users/10548/STM32Cube/Repository/STM32Cube_FW_G4_V1.5.1/Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_ll_rcc.c stm32g4xx_ll_utils.c stm32g4xx_ll_exti.c stm32g4xx_ll_gpio.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_ll_adc.c stm32g4xx_ll_dma.c stm32g4xx_hal_fdcan.c stm32g4xx_ll_lptim.c stm32g4xx_ll_spi.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_tim.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group Middlewares/USB_Device_Library
    C:/Users/10548/STM32Cube/Repository/STM32Cube_FW_G4_V1.5.1/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    C:/Users/10548/STM32Cube/Repository/STM32Cube_FW_G4_V1.5.1/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group code
    ../Code/Src/: AS5600.c pid.c foc.c as5047.c
software components: CMSIS:CORE 5.6.0
